SRCDATE = "20180830"

SRC_URI[md5sum] = "829e621064e1f62016e06e76c97724b6"
SRC_URI[sha256sum] = "082ef4a187d39464c8d078a033e11518dfd987c2d96ecbf615f9c4aa54b28190"

COMPATIBLE_MACHINE = "^(dinobot4k|anadol4k|axashis4kcombo|dinobot4kl|anadol4kv2|axashis4kcomboplus|dinobot4kplus|dinobot4kpro|dinobotu55|iziboxx3|axashisc4k|vipersingle|viper4kv20|iziboxelite4k|dinobot4ktwin)$"

require dinobot-opengl.inc
