require dinobot-stb-kodi.inc

COMPATIBLE_MACHINE = "^(dinobotu55|iziboxx3)$"
