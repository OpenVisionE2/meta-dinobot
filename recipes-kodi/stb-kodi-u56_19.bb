require dinobot-stb-kodi.inc

COMPATIBLE_MACHINE = "^(axashisc4k)$"
