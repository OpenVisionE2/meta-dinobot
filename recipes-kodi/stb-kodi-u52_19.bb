require dinobot-stb-kodi.inc

COMPATIBLE_MACHINE = "^(axashis4kcomboplus|dinobot4kplus)$"
