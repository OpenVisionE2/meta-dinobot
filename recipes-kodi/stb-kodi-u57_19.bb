require dinobot-stb-kodi.inc

COMPATIBLE_MACHINE = "^(vipersingle|viper4kv20|iziboxelite4k|dinobot4ktwin)$"
