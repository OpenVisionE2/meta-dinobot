require dinobot-stb-kodi.inc

COMPATIBLE_MACHINE = "^(arivacombo)$"
