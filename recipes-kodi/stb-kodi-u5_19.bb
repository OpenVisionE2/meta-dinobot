require dinobot-stb-kodi.inc

COMPATIBLE_MACHINE = "^(dinobot4k|anadol4k)$"
