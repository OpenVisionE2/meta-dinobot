require dinobot-stb-kodi.inc

COMPATIBLE_MACHINE = "^(arivatwin)$"
