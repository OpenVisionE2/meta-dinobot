require dinobot-stb-kodi.inc

COMPATIBLE_MACHINE = "^(axashis4kcombo|dinobot4kl|anadol4kv2)$"
