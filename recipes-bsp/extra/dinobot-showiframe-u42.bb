require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "^(anadolprohd5)$"

SRCDATE = "20200507"

SRC_URI[md5sum] = "220d699602a2b14e1d600c3a8be76af6"
SRC_URI[sha256sum] = "93d77259955ba8dd84a2798dfb4059e260412430066bf787cd839b4521151c17"
