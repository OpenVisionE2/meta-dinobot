SRCDATE = "20190716"

SRC_URI[newgeneration.md5sum] = "20363ec258cd283cb89908cbd132809e"
SRC_URI[newgeneration.sha256sum] = "0f68f71dd3abbc2df8169900bc87165b768bd17bbf2b9871de76d534b2d5752b"

require dinobot-partitions.inc
