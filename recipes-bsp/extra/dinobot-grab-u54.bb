require dinobot-grab.inc

COMPATIBLE_MACHINE = "^(dinobot4kpro)$"

SRCDATE = "20191230"

SRC_URI[md5sum] = "2379a64a23dc74250e379017923d431f"
SRC_URI[sha256sum] = "9b3d7949211b5f51ab11ad9b23a9a9a92cf31fc58932b3793254c3fac8a02b8d"
