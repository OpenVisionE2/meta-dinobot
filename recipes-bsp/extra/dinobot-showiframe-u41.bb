require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "dinoboth265|axashistwin"

SRCDATE = "20190620"

SRC_URI[md5sum] = "a9cdd71a0617cbd065dc7a28f9d5a263"
SRC_URI[sha256sum] = "fa9be1fb16b47cb59aac3597cabe3e0cc0c848693f60af3b248320fcde6ed102"
