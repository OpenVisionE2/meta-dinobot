require dinobot-grab.inc

COMPATIBLE_MACHINE = "^(axashisc4k)$"

SRCDATE = "20200602"

SRC_URI[md5sum] = "08c54059b58ce9ec0d50cbd81ccb8c1c"
SRC_URI[sha256sum] = "84d075545ec3616d45d99cd48e95e0b902201af023452079cf2324d2b7bb128d"
