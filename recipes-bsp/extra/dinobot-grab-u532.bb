require dinobot-grab.inc

COMPATIBLE_MACHINE = "arivacombo"

SRCDATE = "20190717"

SRC_URI[md5sum] = "9e85ecc4f66c8e21ef8abf08d94a13f3"
SRC_URI[sha256sum] = "06b2d3776967749f5036535a94a6add7f93922d8b15a68c03dac798ecdfdd8c0"
