require dinobot-grab.inc

COMPATIBLE_MACHINE = "dinobotu55"

SRCDATE = "20190619"

SRC_URI[md5sum] = "84c226c327446a3df43a72a81dda4cc0"
SRC_URI[sha256sum] = "d31ff3c0e712fb319ba61b905ba5f32bfd4c009a49fb93374ffbbc0dabb32aca"
