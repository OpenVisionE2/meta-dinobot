SRCDATE = "20190319"
MACHINETYPE = "u51"
require dinobot-libs2.inc

SRC_URI[md5sum] = "8d5a0918fc0b7d3054d284a4dff01e01"
SRC_URI[sha256sum] = "b7010711f62374a47d137d10ba67946543385c36153b18e64773c10ba92492bb"

COMPATIBLE_MACHINE = "axashis4kcombo|dinobot4kl|anadol4kcombo|anadol4kv2"
