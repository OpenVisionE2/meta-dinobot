require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "arivatwin"

SRCDATE = "20190906"

SRC_URI[md5sum] = "5627fa55c82a9eb1f2d6294d01db68ed"
SRC_URI[sha256sum] = "f6977161fe171c3b6a217042a3282cf9b2e482fbb556bdeb6b3d65783dd98a08"
