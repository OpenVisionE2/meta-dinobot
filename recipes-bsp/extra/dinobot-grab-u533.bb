require dinobot-grab.inc

COMPATIBLE_MACHINE = "^(arivatwin)$"

SRCDATE = "20191025"

SRC_URI[md5sum] = "0d1f7783f383dc37eb9a34b50e44933a"
SRC_URI[sha256sum] = "cb2b9295c1ca00492d19dc35a18f7dd5ef6053ca22cd92fe08a6e8d42f3dc1d7"
