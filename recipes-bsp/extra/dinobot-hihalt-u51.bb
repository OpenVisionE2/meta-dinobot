SRCDATE = "20190508"
MACHINETYPE = "u51"

SRC_URI[md5sum] = "ea1366c2b82eeb5721343e34419ac9c7"
SRC_URI[sha256sum] = "ff42703973f1f7dfde500d6d65516bf82b1dad5ab27bc6e130081ed1aa837289"

require dinobot-hihalt.inc

COMPATIBLE_MACHINE = "axashis4kcombo|dinobot4kl|anadol4kcombo|anadol4kv2"
