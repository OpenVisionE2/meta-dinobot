SRCDATE = "20190506"
MACHINETYPE = "u41"

SRC_URI[md5sum] = "8736b2a7fdb2bf54fc2ee233098a1891"
SRC_URI[sha256sum] = "cb251d8a9337d35c4470895bf839335c44081b68fc53fb9be0a72e934b854c1b"

require dinobot-hihalt.inc

COMPATIBLE_MACHINE = "dinoboth265|axashistwin"
