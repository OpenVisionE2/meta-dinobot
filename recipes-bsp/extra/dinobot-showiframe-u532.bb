require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "^(arivacombo)$"

SRCDATE = "20191025"

SRC_URI[md5sum] = "c0be8f079706f6abeb4d87f01a4e03b3"
SRC_URI[sha256sum] = "d111856e977a9d533bcb13207023aa0f5bdd2f5bc7a563026e68b6b98ea8c227"
