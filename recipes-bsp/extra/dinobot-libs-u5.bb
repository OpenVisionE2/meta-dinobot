SRCDATE = "20181128"
MACHINETYPE = "u5"
require dinobot-libs2.inc

SRC_URI[md5sum] = "a2555923b6484b04386d29e56e325871"
SRC_URI[sha256sum] = "28615b3b61f222f8406aedd431556b53202369cbe6a792f2acf64ca9ff632d4d"

COMPATIBLE_MACHINE = "mediabox4k|dinobot4k|anadol4k"
