SRCDATE = "20190509"
MACHINETYPE = "u56"
require dinobot-libs2.inc

SRC_URI[md5sum] = "3b2ee5537d466f7aac1a69066e0fdb36"
SRC_URI[sha256sum] = "4d63a267d94726e00ccd1b38868618f52d00a5bbf99784e4ae28a27cfe31c140"

COMPATIBLE_MACHINE = "axashisc4k"
