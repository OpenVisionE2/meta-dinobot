require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "dinobotu43"

SRCDATE = "20190620"

SRC_URI[md5sum] = "09d53e0f69dc69e0eb2589fc776fef83"
SRC_URI[sha256sum] = "593e9f68c6d1b179ba5fc45ab99a1da9f09ecd5afbd340cf9f824b91d285504b"
