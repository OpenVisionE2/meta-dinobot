require dinobot-grab.inc

COMPATIBLE_MACHINE = "^(dinobot4k|anadol4k)$"

SRCDATE = "20200710"

SRC_URI[md5sum] = "f4c1730ad16184eafdf1c746c07e32a4"
SRC_URI[sha256sum] = "20dbc41ee7903a6a07b7bb30a17463ad5470b178d5a1db58142e76abaf5cc85a"
