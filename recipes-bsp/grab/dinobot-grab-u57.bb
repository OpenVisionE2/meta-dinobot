require dinobot-grab.inc

COMPATIBLE_MACHINE = "^(vipersingle|viper4kv20|iziboxelite4k|dinobot4ktwin)$"

SRCDATE = "20210604"

SRC_URI[md5sum] = "49685aba25230d788602307e70c991e6"
SRC_URI[sha256sum] = "ffb46d89d3619f91ed9d7fbcdbe3915636c2d65258e85671e380a91309c6200e"
