require dinobot-grab.inc

COMPATIBLE_MACHINE = "^(dinobotu43|turing)$"

SRCDATE = "20200710"

SRC_URI[md5sum] = "a41231b5e601a145f856c0b9ce9b1be2"
SRC_URI[sha256sum] = "0c2f0a36fbe22ed4fe212afecf271cf130b01edcad936f0f7bf8eecadf3e8db5"
