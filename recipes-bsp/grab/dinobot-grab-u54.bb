require dinobot-grab.inc

COMPATIBLE_MACHINE = "^(dinobot4kpro)$"

SRCDATE = "20200710"

SRC_URI[md5sum] = "8226a4a771551aeb7e68d67f16a3dbec"
SRC_URI[sha256sum] = "16ff46b475ff1df2c51b593c7064e5ea6fe3c2c1413fe8803ee9e59e87733a8f"
