require dinobot-grab.inc

COMPATIBLE_MACHINE = "^(axashistwinplus)$"

SRCDATE = "20210325"

SRC_URI[md5sum] = "c9bacca50f6279f04381630bacf8834e"
SRC_URI[sha256sum] = "a275f4d2d68f9313add518a8ac903cd2396af35f1caf2108ae83ea66e110a249"
