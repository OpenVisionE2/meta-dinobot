require dinobot-grab.inc

COMPATIBLE_MACHINE = "^(axashis4kcombo|dinobot4kl|anadol4kv2)$"

SRCDATE = "20200710"

SRC_URI[md5sum] = "c576818e776b3513bf038d8057f16fbb"
SRC_URI[sha256sum] = "e1f5ef7d99199de41fd42eeb5479b7b8905c54f50dba01db7b74aa245be0342c"
