require dinobot-grab.inc

COMPATIBLE_MACHINE = "^(axashisc4k)$"

SRCDATE = "20200710"

SRC_URI[md5sum] = "171f900fc6f97354b34efed842b6fead"
SRC_URI[sha256sum] = "7412673a445c086bc5f9cd0ab7a44ee390a7c255ce2d50e9f59b961b6e1d04f6"
