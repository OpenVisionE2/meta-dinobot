require dinobot-grab.inc

COMPATIBLE_MACHINE = "^(axashis4kcomboplus|dinobot4kplus)$"

SRCDATE = "20200710"

SRC_URI[md5sum] = "444001e62abdfe7c964f2406f76531aa"
SRC_URI[sha256sum] = "19a9f875e61f0fc7f8a92c2d0f8e5057f36d8da69b784d30d7700a6b3e31dc9c"
