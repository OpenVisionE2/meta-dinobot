require dinobot-grab.inc

COMPATIBLE_MACHINE = "^(anadolprohd5)$"

SRCDATE = "20200710"

SRC_URI[md5sum] = "e00f74d499eabe0e9c08049d341550e0"
SRC_URI[sha256sum] = "b0eb2c6522971d295982315fe0999fdd1055a17a991a7783308fd39d19062442"
