require dinobot-grab.inc

COMPATIBLE_MACHINE = "^(dinoboth265|axashistwin|protek4kx1)$"

SRCDATE = "20210607"

SRC_URI[md5sum] = "af22b7f5d29ecd57f8374475bbc53d4b"
SRC_URI[sha256sum] = "2bbd33c6059a823ce7b11de6662a2d0d2feb745ab07822773546c57f19c35cc6"
