require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "^(dinobotu43|turing)$"

SRCDATE = "20200710"

SRC_URI[md5sum] = "be2b910fb720a8681aa87116e527ac94"
SRC_URI[sha256sum] = "ab75c916e12c755a48c8825607984bb5b23834129577b1412547fe996ff9098c"
