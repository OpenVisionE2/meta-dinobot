require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "^(dinoboth265|axashistwin|protek4kx1)$"

SRCDATE = "20200710"

SRC_URI[md5sum] = "2c7ac2f71c10b4c5ea8b7ca67cf48300"
SRC_URI[sha256sum] = "1fc1bde965d7b6c6f6a6b99442186d49e99436f27981f5ce75a9eef6caa48131"
