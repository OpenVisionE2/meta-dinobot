require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "^(anadolprohd5)$"

SRCDATE = "20210607"

SRC_URI[md5sum] = "17f8ba5c12ea0a9b48bfa2391d5a99a4"
SRC_URI[sha256sum] = "13bef3e35533a7781689d7568479056a51c560746dbd96538d1efdeac237ff96"
