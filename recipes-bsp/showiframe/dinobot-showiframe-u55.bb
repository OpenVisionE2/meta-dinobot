require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "^(dinobotu55|iziboxx3)$"

SRCDATE = "20200710"

SRC_URI[md5sum] = "d1c8ba81ab63243369c702719d6f251e"
SRC_URI[sha256sum] = "003bbf9c83a527ff023f62e726f67d43833d92fecf13f0b47fe64674fb5cee5d"
