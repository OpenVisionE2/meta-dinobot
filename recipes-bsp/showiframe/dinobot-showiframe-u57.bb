require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "^(vipers|viper4kv20)$"

SRCDATE = "20200811"

SRC_URI[md5sum] = "f965c54da6ccdf22c786faee5aeac56c"
SRC_URI[sha256sum] = "0047adc546545a8e4d54deb98dcce109e502f4d8a5bef8f0dfdc934a86d65eec"
