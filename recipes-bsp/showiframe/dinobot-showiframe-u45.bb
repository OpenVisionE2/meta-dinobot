require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "^(axashistwinplus)$"

SRCDATE = "20210325"

SRC_URI[md5sum] = "af50264e52485f2cfd80685689b92d77"
SRC_URI[sha256sum] = "32d43a72d834a819bdfed67a586fe7016bf81af62edeeda4f380ed0aa4716c8a"
