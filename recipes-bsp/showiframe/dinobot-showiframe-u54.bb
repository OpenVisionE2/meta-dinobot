require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "^(dinobot4kpro)$"

SRCDATE = "20200710"

SRC_URI[md5sum] = "cf942a7756d18553e11262b8634a3a37"
SRC_URI[sha256sum] = "bb0592ce6cc093a86eb1b79a390ab2a1a1104501a4fd7218d138f441f22654b0"
