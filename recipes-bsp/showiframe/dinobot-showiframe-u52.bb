require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "^(axashis4kcomboplus|dinobot4kplus)$"

SRCDATE = "20200710"

SRC_URI[md5sum] = "7a57485fae31d4a7948fe18e9cb9331d"
SRC_URI[sha256sum] = "6fbd53d7411081689862ee1b85bad33ecd95343588e209467bd87733915a5860"
