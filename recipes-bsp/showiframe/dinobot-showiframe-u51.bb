require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "^(axashis4kcombo|dinobot4kl|anadol4kv2)$"

SRCDATE = "20200710"

SRC_URI[md5sum] = "edde886f56018eb2d12640a770ec8f84"
SRC_URI[sha256sum] = "13fd2a76f4269ad22fd3db024ed36d6b178c39e4f87796cb49efed41454e66f9"
