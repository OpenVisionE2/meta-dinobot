SRCDATE = "20190509"
MACHINETYPE = "u55"

SRC_URI[md5sum] = "fb851da22da96bc223552abd70ed7696"
SRC_URI[sha256sum] = "88e2f679a0277fd2732dc0922c0615858f93386e0e6c8dc7856db2e4645bdf4d"

require dinobot-blindscan.inc

COMPATIBLE_MACHINE = "dinobotu55"
