KV = "4.4.35"
SRCDATE = "20190318"
MACHINETYPE = "u52"

require dinobot-dvb-modules2.inc

SRC_URI[md5sum] = "85209ba8c653e6b944f30377c4deeb9f"
SRC_URI[sha256sum] = "5a04ce90cabfd79d838db74daa446b3fc5267d0a68f54919f94ffe0fd3b30632"

COMPATIBLE_MACHINE = "axashis4kcomboplus|dinobot4kplus"
