SRCDATE = "20190726"

SRC_URI[md5sum] = "bc38a47b00af54fc39409cf4873d94b2"
SRC_URI[sha256sum] = "7eb047f6853df7a0a4527fab0f1d6e398a40fab788517d930643796b1fbe101a"

require dinobot-blindscan.inc

COMPATIBLE_MACHINE = "dinoboth265|axashistwin|protek4kx1"
