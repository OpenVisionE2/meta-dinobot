SRCDATE = "20190308"
MACHINETYPE = "u52"

SRC_URI[md5sum] = "bb597f4ec79e9a037902971a115ece94"
SRC_URI[sha256sum] = "a1fcb99f152e297ce2381399fc14b68ebf913aa7e248260a967ae08ecd33b294"

require dinobot-blindscan.inc

COMPATIBLE_MACHINE = "axashis4kcomboplus|dinobot4kplus"