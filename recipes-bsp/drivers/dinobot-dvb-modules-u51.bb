KV = "4.4.35"
SRCDATE = "20181022"
MACHINETYPE = "u51"

require dinobot-dvb-modules2.inc

SRC_URI[md5sum] = "fed6e3bc9b5f4dc142565af43c196e1b"
SRC_URI[sha256sum] = "4292d8f997f9007f6c7bb3ec150dd8503ebb41a342d597eaa39e94e07dd2e80c"

COMPATIBLE_MACHINE = "axashis4kcombo|dinobot4kl|anadol4kcombo|anadol4kv2"
