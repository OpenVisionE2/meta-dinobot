SRCDATE = "20200624"

require dinobot-dvb-modules2.inc

SRC_URI[md5sum] = "a0175932bbdbc7e0600cbf1bb2f3945f"
SRC_URI[sha256sum] = "4f483a36092553e3b3852f4bd344c7a4afb6cfe48c93045843cccb1f670eac67"

COMPATIBLE_MACHINE = "^(dinobotu55|iziboxx3)$"
