SRCDATE = "20190412"
MACHINETYPE = "u51"

SRC_URI[md5sum] = "c83a19f8d9240da98491cb4f2578c505"
SRC_URI[sha256sum] = "750e51eac73cb5a7682abc070f7d8d859205a9f1757c8682115a47eef57912c5"

require dinobot-blindscan.inc

COMPATIBLE_MACHINE = "axashis4kcombo|dinobot4kl|anadol4kcombo|anadol4kv2"
